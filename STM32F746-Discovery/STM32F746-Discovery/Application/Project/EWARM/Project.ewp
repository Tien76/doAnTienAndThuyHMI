# IAR project Project.ewp, settings and files
configuration STM32F746-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=1; EW_USE_EXTERNAL_FLASH=1; EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource; EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\ThirdParty\STM32Cube_FW_F7\Drivers\CMSIS\Include; ..\..\..\ThirdParty\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\ThirdParty\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\ThirdParty\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\ThirdParty\STM32Cube_FW_F7\Drivers\BSP\Components\Common; ..\..\Source; ..\..\..\TargetSpecific; ..\..\..\TargetSpecific\Drivers; ..\..\GeneratedCode; ..\..\..\PlatformPackage\RTE; ..\..\GeneratedCode\EmWiGfxInclude; ..\..\..\ThirdParty\STM32Cube_FW_F7\MiddleWares\Third_Party\FreeRTOS\Source\include; ..\..\..\ThirdParty\STM32Cube_FW_F7\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\ThirdParty\STM32Cube_FW_F7\MiddleWares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-STM32F746-Discovery.hex
  ILINK.IlinkOutputFile: EmbeddedWizard-STM32F746-Discovery.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c main.c
    ./: startup_stm32f746xx.s
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_system.c ew_bsp_touch.c stm32f7xx_it.c system_stm32f7xx.c
  group Application/TargetSpecific/Drivers
    ../../../TargetSpecific/Drivers/: ft5336.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32746G_Discovery
    ../../../ThirdParty/STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_qspi.c stm32746g_discovery_sdram.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: Application.c Core.c Cutter.c Effects.c Graphics.c Resources.c Views.c
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: ewextgfx.c libewgfx-m7-iar.a
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewextrte.c libewrte-m7-iar.a
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_F7/MiddleWares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
